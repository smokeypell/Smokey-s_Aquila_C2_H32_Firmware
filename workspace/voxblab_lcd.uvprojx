# Keil uVision project voxblab_lcd.uvprojx, settings and files
target firmware_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.7
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: voxelab +hex
  AfterMake: c:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  .\bin\firmware.bin  .\obj\voxelab.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: HC32F46x,USE_DEVICE_DRIVER_LIB,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__MPU_PRESENT=1,__STM32F1__,STM32_HIGH_DENSITY,ARDUINO_ARCH_STM32F1,ARDUINO_ARCH_STM32
  c misc: --gnu --diag_suppress=186,66 --cpp11
  c include: ..\source\compoment\adc;..\source\compoment\i2c;..\source\compoment\sdio;..\source\compoment\sdio\sd_card\inc;..\source\compoment\spi;..\source\compoment\uart;..\source\compoment\Utility;..\source\drivers\board;..\source\drivers\library;..\source\drivers\library\inc;..\source\framework\cores;..\source\framework\U8glib-HAL;..\source\framework\U8glib-HAL\clib;..\source\framework\U8glib-HAL\clib\HAL_example_files;..\source\main;..\source\main\hdsc32core;..\source\marlin;..\source\marlin\src;..\source\marlin\src\core;..\source\marlin\src\feature;..\source\marlin\src\gcode;..\source\marlin\src\HAL;..\source\marlin\src\HAL\shared;..\source\marlin\src\pins;..\source\marlin\src\HAL\shared\backtrace;..\source\marlin\src\HAL\shared\cpu_exception;..\source\marlin\src\HAL\STM32F1;..\source\marlin\src\HAL\STM32F1\inc;..\source\marlin\src\HAL\STM32F1\tft;..\source\marlin\src\inc;..\source\marlin\src\lcd;..\source\marlin\src\lcd\dogm;..\source\marlin\src\lcd\dogm\fontdata;..\source\marlin\src\lcd\dogm\status;..\source\marlin\src\lcd\dwin;..\source\marlin\src\lcd\dwin\e3v2;..\source\marlin\src\lcd\extui;..\source\marlin\src\lcd\language;..\source\marlin\src\lcd\menu;..\source\marlin\src\libs;..\source\marlin\src\module;..\source\marlin\src\module\stepper;..\source\marlin\src\module\thermistor;..\source\marlin\src\pins;..\source\marlin\src\pins\stm32f1;..\source\marlin\src\sd
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep=*Handler
  group drivers
    ../source/drivers/library/src/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_crc.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
    ../source/drivers/library/inc/: hc32f46x_adc.h hc32f46x_aes.h hc32f46x_can.h hc32f46x_clk.h hc32f46x_cmp.h hc32f46x_crc.h hc32f46x_dcu.h hc32f46x_dmac.h hc32f46x_efm.h hc32f46x_emb.h hc32f46x_event_port.h hc32f46x_exint_nmi_swi.h hc32f46x_gpio.h hc32f46x_hash.h hc32f46x_i2c.h hc32f46x_i2s.h hc32f46x_icg.h hc32f46x_interrupts.h hc32f46x_keyscan.h hc32f46x_mpu.h hc32f46x_ots.h hc32f46x_pwc.h hc32f46x_qspi.h hc32f46x_rmu.h hc32f46x_rtc.h hc32f46x_sdioc.h hc32f46x_spi.h hc32f46x_sram.h hc32f46x_swdt.h hc32f46x_timer0.h hc32f46x_timer4_cnt.h hc32f46x_timer4_emb.h hc32f46x_timer4_oco.h hc32f46x_timer4_pwm.h hc32f46x_timer4_sevt.h hc32f46x_timer6.h hc32f46x_timera.h hc32f46x_trng.h hc32f46x_usart.h hc32f46x_utility.h hc32f46x_wdt.h
  group main
    ../source/main/: ddl_config.h main.cpp
    ../source/main/hdsc32core/: core_cm4.h hc32_common.h hc32_ddl.h hc32f460petb.h startup_hc32f460petb.s stdint.h stdio.h system_hc32f460petb.c system_hc32f460petb.h
    ./: g8.lib
  group marlin
    ../source/Marlin/: _Bootscreen.h _Statusscreen.h Configuration.h Configuration_adv.h Version.h
    ../source/Marlin/src/: MarlinCore.cpp MarlinCore.h
  group marlin_cores
    ../source/Marlin/src/core/: boards.h bug_on.h debug_out.h debug_section.h drivers.h language.h macros.h millis_t.h multi_language.h serial.cpp serial.h serial_base.h serial_hook.h types.h utility.cpp utility.h
  group marlin_feature
    ../source/Marlin/src/feature/: babystep.cpp babystep.h controllerfan.h fwretract.h pause.h powerloss.cpp powerloss.h twibus.h backlash.cpp backlash.h baricuda.cpp baricuda.h binary_stream.cpp binary_stream.h bltouch.cpp bltouch.h cancel_object.cpp cancel_object.h caselight.cpp caselight.h closedloop.cpp closedloop.h controllerfan.cpp cooler.cpp cooler.h direct_stepping.cpp direct_stepping.h e_parser.cpp e_parser.h encoder_i2c.cpp encoder_i2c.h ethernet.cpp ethernet.h fanmux.cpp fanmux.h filwidth.cpp filwidth.h fwretract.cpp host_actions.cpp host_actions.h hotend_idle.cpp hotend_idle.h joystick.cpp joystick.h max7219.cpp max7219.h meatpack.cpp meatpack.h mixing.cpp mixing.h pause.cpp power.cpp power.h power_monitor.cpp power_monitor.h probe_temp_comp.cpp probe_temp_comp.h repeat.cpp repeat.h runout.cpp runout.h solenoid.cpp solenoid.h spindle_laser.cpp spindle_laser.h spindle_laser_types.h stepper_driver_safety.cpp stepper_driver_safety.h tmc_util.cpp tmc_util.h tramming.cpp tramming.h twibus.cpp z_stepper_align.cpp z_stepper_align.h
    ../source/Marlin/src/feature/bedlevel/abl/: abl.cpp abl.h
    ../source/Marlin/src/feature/bedlevel/mbl/: mesh_bed_leveling.cpp mesh_bed_leveling.h
    ../source/Marlin/src/feature/bedlevel/ubl/: ubl.cpp ubl.h ubl_G29.cpp ubl_motion.cpp
    ../source/Marlin/src/feature/bedlevel/: bedlevel.cpp bedlevel.h hilbert_curve.cpp hilbert_curve.h
  group marlin_gcode
    ../source/Marlin/src/gcode/calibrate/: G28.cpp G33.cpp G34.cpp G34_M422.cpp G76_M192_M871.cpp G425.cpp M12.cpp M48.cpp M100.cpp M425.cpp M665.cpp M666.cpp M852.cpp
    ../source/Marlin/src/gcode/config/: M92.cpp M200-M205.cpp M220.cpp M221.cpp M301.cpp M302.cpp M304.cpp M309.cpp M43.cpp M217.cpp M218.cpp M281.cpp M305.cpp M540.cpp M575.cpp M672.cpp
    ../source/Marlin/src/gcode/control/: M17_M18_M84.cpp M80_M81.cpp M85.cpp M108_M112_M410.cpp M111.cpp M120_M121.cpp M211.cpp M400.cpp M993_M994.cpp M997.cpp M999.cpp T.cpp M3-M5.cpp M7-M9.cpp M10-M11.cpp M42.cpp M226.cpp M280.cpp M350_M351.cpp M380_M381.cpp M605.cpp
    ../source/Marlin/src/gcode/eeprom/: M500-M504.cpp
    ../source/Marlin/src/gcode/feature/digipot/: M907-M910.cpp
    ../source/Marlin/src/gcode/feature/pause/: G27.cpp G60.cpp G61.cpp M125.cpp M600.cpp M603.cpp M701_M702.cpp
    ../source/Marlin/src/gcode/feature/powerloss/: M413.cpp M1000.cpp
    ../source/Marlin/src/gcode/geometry/: G92.cpp M206_M428.cpp G17-G19.cpp G53-G59.cpp
    ../source/Marlin/src/gcode/host/: M110.cpp M113.cpp M114.cpp M115.cpp M118.cpp M119.cpp M16.cpp M360.cpp M876.cpp
    ../source/Marlin/src/gcode/lcd/: M0_M1.cpp M117.cpp M145.cpp M300.cpp M414.cpp M73.cpp M250.cpp M995.cpp
    ../source/Marlin/src/gcode/motion/: G0_G1.cpp G2_G3.cpp G4.cpp M290.cpp G5.cpp G6.cpp G80.cpp
    ../source/Marlin/src/gcode/sd/: M20.cpp M21_M22.cpp M23.cpp M24_M25.cpp M26.cpp M27.cpp M28_M29.cpp M30.cpp M32.cpp M33.cpp M34.cpp M524.cpp M928.cpp M1001.cpp
    ../source/Marlin/src/gcode/stats/: M31.cpp M75-M78.cpp
    ../source/Marlin/src/gcode/temp/: M104_M109.cpp M105.cpp M106_M107.cpp M140_M190.cpp M141_M191.cpp M143_M193.cpp M155.cpp M303.cpp
    ../source/Marlin/src/gcode/units/: M82_M83.cpp G20_G21.cpp M149.cpp
    ../source/Marlin/src/gcode/: gcode.cpp gcode.h gcode_d.cpp parser.cpp parser.h queue.cpp queue.h
    ../source/Marlin/src/gcode/bedlevel/: G26.cpp G35.cpp G42.cpp M420.cpp
    ../source/Marlin/src/gcode/feature/advance/: M900.cpp
    ../source/Marlin/src/gcode/feature/baricuda/: M126-M129.cpp
    ../source/Marlin/src/gcode/feature/camera/: M240.cpp
    ../source/Marlin/src/gcode/feature/cancel/: M486.cpp
    ../source/Marlin/src/gcode/feature/caselight/: M355.cpp
    ../source/Marlin/src/gcode/feature/clean/: G12.cpp
    ../source/Marlin/src/gcode/feature/controllerfan/: M710.cpp
    ../source/Marlin/src/gcode/feature/filwidth/: M404-M407.cpp
    ../source/Marlin/src/gcode/feature/fwretract/: G10_G11.cpp M207-M209.cpp
    ../source/Marlin/src/gcode/feature/i2c/: M260_M261.cpp
    ../source/Marlin/src/gcode/feature/L6470/: M122.cpp M906.cpp M916-918.cpp
    ../source/Marlin/src/gcode/feature/leds/: M150.cpp M7219.cpp
    ../source/Marlin/src/gcode/feature/macro/: M810-M819.cpp
    ../source/Marlin/src/gcode/feature/mixing/: M163-M165.cpp M166.cpp
    ../source/Marlin/src/gcode/feature/network/: M552-M554.cpp
    ../source/Marlin/src/gcode/feature/password/: M510-M512.cpp
    ../source/Marlin/src/gcode/feature/power_monitor/: M430.cpp
    ../source/Marlin/src/gcode/feature/prusa_MMU2/: M403.cpp
    ../source/Marlin/src/gcode/feature/runout/: M412.cpp
    ../source/Marlin/src/gcode/feature/trinamic/: M569.cpp M911-M914.cpp
    ../source/Marlin/src/gcode/probe/: G30.cpp G31_G32.cpp G38.cpp M401_M402.cpp M851.cpp M951.cpp
    ../source/Marlin/src/gcode/scara/: M360-M364.cpp
    ../source/Marlin/src/gcode/bedlevel/mbl/: G29.cpp M421.cpp
  group marlin_HAL
    ../source/Marlin/src/HAL/: HAL.h platforms.h
    ../source/Marlin/src/HAL/shared/cpu_exception/: exception_hook.h
    ../source/Marlin/src/HAL/shared/: Delay.cpp Delay.h eeprom_api.cpp eeprom_api.h eeprom_if.h esp_wifi.cpp esp_wifi.h HAL_SPI.h Marduino.h math_32bit.h progmem.h servo.cpp servo.h servo_private.h
    ../source/Marlin/src/HAL/STM32F1/dogm/: u8g_com_stm32duino_swspi.cpp
    ../source/Marlin/src/HAL/STM32F1/inc/: Conditionals_adv.h Conditionals_LCD.h Conditionals_post.h SanityCheck.h
    ../source/Marlin/src/HAL/STM32F1/tft/: tft_fsmc.cpp tft_fsmc.h tft_spi.cpp tft_spi.h xpt2046.cpp xpt2046.h
    ../source/Marlin/src/HAL/STM32F1/: eeprom_bl24cxx.cpp eeprom_flash.cpp eeprom_if_iic.cpp eeprom_sdcard.cpp eeprom_wired.cpp endstop_interrupts.h fastio.h HAL_SPI.cpp pinsDebug.h sdio.cpp SPI.cpp SPI.h spi_pins.h timers.cpp timers.h watchdog.cpp watchdog.h MarlinSerial.h MarlinSPI.h msc_sd.h onboard_sd.h sdio.h
  group marlin_inc
    ../source/Marlin/src/inc/: Conditionals_adv.h Conditionals_LCD.h Conditionals_post.h MarlinConfig.h MarlinConfigPre.h SanityCheck.h Version.h
  group marlin_lcd
    ../source/Marlin/src/lcd/dogm/: dogm_Bootscreen.h dogm_Statusscreen.h HAL_LCD_class_defines.h HAL_LCD_com_defines.h marlinui_DOGM.h status_screen_lite_ST7920.h u8g_fontutf8.h ultralcd_st7920_u8glib_rrd_AVR.h marlinui_DOGM.cpp
    ../source/Marlin/src/lcd/dwin/: dwin_lcd.cpp dwin_lcd.h
    ../source/Marlin/src/lcd/dwin/e3v2/: dwin.cpp dwin.h rotary_encoder.cpp rotary_encoder.h
    ../source/Marlin/src/lcd/extui/: ui_api.cpp ui_api.h
    ../source/Marlin/src/lcd/menu/: menu.cpp menu.h menu_addon.h menu_advanced.cpp menu_backlash.cpp menu_bed_corners.cpp menu_bed_leveling.cpp menu_cancelobject.cpp menu_configuration.cpp menu_delta_calibrate.cpp menu_filament.cpp menu_game.cpp menu_info.cpp menu_item.h menu_job_recovery.cpp menu_language.cpp menu_led.cpp menu_main.cpp menu_media.cpp menu_mixer.cpp menu_mmu2.cpp menu_mmu2.h menu_motion.cpp menu_password.cpp menu_power_monitor.cpp menu_probe_offset.cpp menu_spindle_laser.cpp menu_temperature.cpp menu_tmc.cpp menu_touch_screen.cpp menu_tramming.cpp menu_tune.cpp menu_ubl.cpp
    ../source/Marlin/src/lcd/: buttons.h fontutils.cpp fontutils.h lcdprint.cpp lcdprint.h marlinui.cpp marlinui.h scaled_tft.h thermistornames.h
    ../source/Marlin/src/lcd/dogm/status/: bed.h chamber.h combined.h cooler.h cutter.h fan.h hotend.h
    ../source/Marlin/src/lcd/dogm/fontdata/: fontdata_6x9_marlin.h fontdata_ISO10646_1.h langdata_an.h langdata_bg.h langdata_ca.h langdata_cz.h langdata_da.h langdata_de.h langdata_el.h langdata_el_gr.h langdata_en.h langdata_es.h langdata_eu.h langdata_fi.h langdata_fr.h langdata_gl.h langdata_hr.h langdata_hu.h langdata_it.h langdata_jp_kana.h langdata_ko_KR.h langdata_nl.h langdata_pl.h langdata_pt.h langdata_pt_br.h langdata_ro.h langdata_ru.h langdata_sk.h langdata_test.h langdata_tr.h langdata_uk.h langdata_vi.h langdata_zh_CN.h langdata_zh_TW.h
    ../source/Marlin/src/lcd/language/: language_an.h language_bg.h language_ca.h language_cz.h language_da.h language_de.h language_el.h language_el_gr.h language_en.h language_es.h language_eu.h language_fi.h language_fr.h language_gl.h language_hr.h language_hu.h language_it.h language_jp_kana.h language_ko_KR.h language_nl.h language_pl.h language_pt.h language_pt_br.h language_ro.h language_ru.h language_sk.h language_sv.h language_test.h language_tr.h language_uk.h language_vi.h language_zh_CN.h language_zh_TW.h
  group marlin_libs
    ../source/Marlin/src/libs/: autoreport.h BL24CXX.cpp BL24CXX.h buzzer.cpp buzzer.h circularqueue.h crc16.cpp crc16.h duration_t.h hex_print.h nozzle.cpp nozzle.h numtostr.cpp numtostr.h stopwatch.cpp stopwatch.h vector_3.cpp vector_3.h
  group marlin_module
    ../source/Marlin/src/module/stepper/: indirection.cpp indirection.h
    ../source/Marlin/src/module/: endstops.cpp endstops.h motion.cpp motion.h planner.cpp planner.h printcounter.h probe.h settings.cpp settings.h stepper.cpp stepper.h temperature.cpp temperature.h tool_change.cpp tool_change.h
  group marlin_pins
    ../source/Marlin/src/pins/stm32f1/: pins_CREALITY_V427.h
    ../source/Marlin/src/pins/: pins.h pins_postprocess.h pinsDebug.h pinsDebug_list.h sensitive_pins.h
  group marlin_sd
    ../source/Marlin/src/sd/: cardreader.cpp cardreader.h disk_io_driver.h Sd2Card.cpp Sd2Card.h Sd2Card_sdio.h SdBaseFile.cpp SdBaseFile.h SdFatConfig.h SdFatStructs.h SdFatUtil.cpp SdFatUtil.h SdFile.cpp SdFile.h SdInfo.h SdVolume.cpp SdVolume.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0
